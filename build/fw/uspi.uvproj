# Keil uVision project uspi.uvproj, settings and files
target RAM (ARM-ADS)
  device: AT91SAM7S64 Atmel
  cpu: IRAM(0x200000-0x203FFF) IROM(0x100000-0x10FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: uspi
  c flags: Optim=4 oTime=1 wLevel=2
  asm define: REMAP
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x2c00
  memory RVCT9: RAM 0x202c00 size 0x1400
  group src
    ../../fw/: adc.c chanmgr.c cmd.c main.c pio.c spi.c Time.c usb.c intc.c retarget.c serial.c
  group asm
    ../../fw/: SAM7.s SWI.s
target FLASH (ARM-ADS)
  device: AT91SAM7S64 Atmel
  cpu: as above
  output: uspi +hex
  c flags: Optim=4 oTime=1
  c define: FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x200000 size 0x4000
